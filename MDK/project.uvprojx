# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: JCB +hex
  AfterMake: fromelf --bin --output=.\bin\JCB.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\Libraries\inc;..\USER\inc;..\USER\app_cfg;..\USER\app_task;..\USER\base_module;..\USER\board_cfg;..\USER\app_module\adc_capture;..\USER\app_module\base_event;..\USER\app_module\base_state;..\USER\app_module\board_key;..\USER\app_module\charge_ctrl;..\USER\app_module\ir_capture;..\USER\app_module\ir_decode;..\USER\app_module\ir_ota;..\USER\app_module\ir_output;..\USER\app_module\iwdg_reset;..\USER\app_module\lighting_ctrl;..\USER\app_module\ozone_ctrl;..\USER\app_module\pwm_data_output;..\USER\app_module\serial;..\USER\app_module\test_data_process;..\USER\app_module\vacuum_clean_ctrl;..\USER\base_module\util_queue
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../IDEsupport/MDK/: startup_cw32l010.s
    ../Libraries/src/: system_cw32l010.c
  group Driver
    ../Libraries/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_digitalsign.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lptim.c cw32l010_lvd.c cw32l010_pwr.c cw32l010_ram.c cw32l010_rtc.c cw32l010_spi.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_uart.c cw32l010_vc.c i2c_eeprom.c system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group board_cfg
    ../USER/board_cfg/: adc_cfg.c gpio_cfg.c tim_cfg.c
  group app_module
    ../USER/app_module/adc_capture/: adc_capture.c
    ../USER/app_module/base_event/: base_event.c
    ../USER/app_module/base_state/: base_state.c
    ../USER/app_module/board_key/: board_key.c
    ../USER/app_module/charge_ctrl/: charge_ctrl.c
    ../USER/app_module/ir_capture/: ir_capture.c
    ../USER/app_module/ir_decode/: ir_decoder_io_level.c ir.c
    ../USER/app_module/ir_ota/: ir_ota.c
    ../USER/app_module/ir_output/: ir_output.c
    ../USER/app_module/iwdg_reset/: iwdg_reset.c
    ../USER/app_module/lighting_ctrl/: lighting_ctrl.c
    ../USER/app_module/ozone_ctrl/: ozone_ctrl.c
    ../USER/app_module/pwm_data_output/: pwm_data_output.c
    ../USER/app_module/serial/: serial.c
    ../USER/app_module/test_data_process/: test_data_process.c
    ../USER/app_module/vacuum_clean_ctrl/: vacuum_ctrl.c
  group base_module
    ../USER/base_module/util_queue/: util_queue.c
  group app_task
    ../USER/app_task/: main_task.c task_base_mode_process.c task_base_self_det.c task_base_state_process.c task_lighting_ctrl.c
  group app_cfg
    ../USER/app_cfg/: app_config.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.2
